Commit message: Added GPS and wheel encoder data

File: urdf/pioneer1_new.urdf (robot description, URDF)
Before this commit: robot pioneer3dx, 18 links, 17 joints
Joints:
- joint laser_joint: origin xyz=0.16 0 0.1 rpy=0 0 0 -> xyz=0.53 0 0.1 rpy=0 0 0
